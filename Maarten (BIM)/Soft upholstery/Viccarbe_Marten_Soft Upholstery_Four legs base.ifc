Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2016-05-25T16:26:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140322_1515(x64) - Exporter 2015.0.2014.0322 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 25 16:26:28 2016 * Host: DESKTOP-JPLJHI2 * Database: C:\Users\Esteban\AppData\Local\Temp\{C57B9970-E198-44A3-BE20-2338BACEDFBA}\ifc * Database version: 5507 * Database creation date: Wed May 25 16:26:27 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 25 16:26:27 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 25 16:26:27 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Esteban\Desktop\Catalogos\Modificados\Maarten\IFC\Soft upholstery\Viccarbe_Marten_Soft Upholstery_Four legs base.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: MAA4P - Four legs base soft upholstery, Viccarbe_Marten_Soft-Upholstery:MAA4P - Four legs base soft upholstery:5795
In: Level 1
Type - ElementType: MAA4P - Four legs base soft upholstery; Material: Linen - Red - Soft, Linen - Red, Steel, Paint Finish, White
Type - Construction - 4 Legs Base: yes; Swivel Base: no
Type - Dimensions - Depth (inches): 20.08''; Depth (mm): 510 mm; Height (inches): 32.28''; Height (mm): 820 mm; Seat Depth (inches): 14.57''; Seat Depth (mm): 370 mm; Seat Height (inches): 17.72''; Seat Height (mm): 450 mm; Seat Width (inches): 18.90''; Seat Width (mm): 480 mm; Width (inches): 22.44''; Width (mm): 570 mm
Type - Identity Data - Collection: MAARTEN; Content Revision Date: 14/03/2016; Description: Maarten is available in a large quantity of finishes to adapt to different environments. Totally in line with its original design we have made arms in lacquered steel tubing for our successful Maarten chair; Designer: VICTOR CARRASCO; Essays BIFMA: http://www.viccarbe.com/archivos/silla-maarten-4patas-certificado-bifma-en.pdf; General Dimensions (inches): 22.44"x32.28"x20.08"; General Dimensions (mm): 57x82x51 cm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: FOUR LEGS BASE SOFT UPHOLSTERY; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product Service Life: -; Product URL: http://www.viccarbe.com/product.php?id=724f8e8ed413f2f; Reference Code: MAA4P; Series: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-maarten-en-info-98.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: MAA4P - Four legs base soft upholstery; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Arm Material: Steel, Paint Finish, White; Base Material: Steel, Paint Finish, White; Frame Material: Steel, Paint Finish, White; Glides Material: Plastic, Grey; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Lacquers: http://www.viccarbe.com/archivos/VICCARBE_lacquers_lacados.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Seat Material: Linen - Red; Seat Material Soft: Linen - Red - Soft
Type - Other - Category: Furniture; Family Name: Viccarbe_Marten_Soft-Upholstery
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Arms: no
Dimensions - Area: 0.711114 m2; Volume: 0.0111355 m3
Other - Family: Viccarbe_Marten_Soft-Upholstery: MAA4P - Four legs base soft upholstery; Family and Type: Viccarbe_Marten_Soft-Upholstery: MAA4P - Four legs base soft upholstery; Type: Viccarbe_Marten_Soft-Upholstery: MAA4P - Four legs base soft upholstery; Type Id: Viccarbe_Marten_Soft-Upholstery: MAA4P - Four legs base soft upholstery
Phasing - Phase Created: New Construction
